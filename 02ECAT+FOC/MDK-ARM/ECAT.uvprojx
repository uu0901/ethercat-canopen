# Keil uVision project ECAT.uvprojx, settings and files
target ECAT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ECAT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../EtherCAT/Port;../EtherCAT/Src;../FOC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group EtherCAT/Port
    ../EtherCAT/Port/: 9252_HW.c 9252_HW.h GenericTypeDefs.h LAN9252_SPI_SLAVE_IO.c LAN9252_SPI_SLAVE_IO.h SPIDriver.c SPIDriver.h
  group EtherCAT/Src
    ../EtherCAT/Src/: coeappl.c ecatappl.c ecatcoe.c ecateoe.c ecatfoe.c ecatslv.c emcy.c eoeappl.c foeappl.c mailbox.c objdef.c sdoserv.c
  group FOC
    ../FOC/: FOC.c FOC.h FOC_Encoder.c MT6701.c MT6701.h FOC_PLL.c FOC_PLL.h FOC_Filter.c FOC_Filter.h FOC_Math.c FOC_Math.h FOC_MotorStatus.c FOC_MotorStatus.h FOC_PID.c FOC_PID.h FOC_Serial.c FOC_Serial.h FOC_SVPWM.c FOC_SVPWM.h UserData_Function.h UserData_Motor.h UserData_Status.h UserData_UserControl.h FOC_CurrentSense.h
software components: CMSIS:CORE 4.3.0
